* LBR2012T470     SPICE MODEL  ( General Type )
*--------------------------------------------------------------------------------------------------------
* Model Generated by TAIYO YUDEN Corporation (http://www.ty-top.com)
* Version 3.0
* TAIYO YUDEN Control No. 180123NI43EB-FBB
* Copyright(c) 2008 TAIYO YUDEN CO.,LTD. All Rights Reserved.
*--------------------------------------------------------------------------------------------------------
*
* Products Name : Inductors
*
* Characteristics :
*     Inductance : 47 uH , SRF(min) : 11 MHz , DC Resistance(max) : 2.21 Ohm , Rated Current : 75 mA
*     Case Size : 2.0 x 1.25 / 0.079 x 0.049 [mm/inch] , Thickness : 1.25 / 0.049 [mm/inch]
*     (Conditions: Temperature = 25 degC , DC Bias Current/Voltage = 0A / 0V)
*
* External Node Assignments :
*
*  1  o---GGG---o  2
*
*--------------------------------------------------------------------------------------------------------
.SubCkt LBR2012T470 1 2
****************************
Rdc 1 101 1.7
L0 101 111 47.205u
L1 111 121 12.439u
R1 111 121 0.4034
L2 121 131 5.8014u
R2 121 131 4.3119
L3 131 2 8.5544u
R3 131 2 49.014
Rp 101 2 15.617k
Cp 101 2 1.93p
****************************
.ends LBR2012T470
